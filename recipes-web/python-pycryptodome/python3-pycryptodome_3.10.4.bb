SUMMARY = "PyCryptodome is a self-contained Python package of low-level cryptographic primitives."
HOMEPAGE = "https://github.com/Legrandin/pycryptodome"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=accfa6aeaceb3ba96676edf18e78302c"

inherit pypi setuptools3

PYPI_PACKAGE = "pycryptodome"

SRC_URI[md5sum] = "99928e9159797372d7ee9d4a04bdad6e"
SRC_URI[sha256sum] = "40083b0d7f277452c7f2dd4841801f058cc12a74c219ee4110d65774c6a58bef"
