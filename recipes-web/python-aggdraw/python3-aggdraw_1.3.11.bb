SUMMARY = "The aggdraw module implements the basic WCK 2D Drawing Interface on top of the AGG library."
HOMEPAGE = "https://github.com/pytroll/aggdraw"
LICENSE = "UNKNOWN"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e70759aff586465bd15114edcb49cb45"

inherit pypi setuptools3

PYPI_PACKAGE = "aggdraw"

SRC_URI[md5sum] = "371261e63052d9ea86b04bec5125309d"
SRC_URI[sha256sum] = "d9803aea0c06dc74ffb3b3eb19d613efe719e7c89940bcdb617ede202b390e8e"
